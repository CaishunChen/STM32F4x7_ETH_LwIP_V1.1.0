# Keil uVision project Project.uvproj, settings and files
target STM324xG_EVAL (ARM-ADS)
  device: STM32F407IG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: STM324xG_EVAL
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40XX,USE_STM324xG_EVAL
  c include: ..\inc;..\..\..\..\Libraries\CMSIS\Include;..\..\..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\..\..\Libraries\STM32F4x7_ETH_Driver\inc;..\..\..\..\Utilities\STM32_EVAL\Common;..\..\..\..\Utilities\STM32_EVAL\STM3240_41_G_EVAL;..\..\..\..\Utilities\Third_Party\lwip-1.4.1\src\include;..\..\..\..\Utilities\Third_Party\lwip-1.4.1\src\include\lwip;..\..\..\..\Utilities\Third_Party\lwip-1.4.1\src\include\netif;..\..\..\..\Utilities\Third_Party\lwip-1.4.1\src\include\ipv4;..\..\..\..\Utilities\Third_Party\lwip-1.4.1\port\STM32F4x7;..\..\..\..\Utilities\Third_Party\lwip-1.4.1\port\STM32F4x7\FreeRTOS;..\..\..\..\Utilities\Third_Party\FreeRTOSV7.3.0\portable\RVDS\ARM_CM3;..\..\..\..\Utilities\Third_Party\FreeRTOSV7.3.0\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CMSIS
    ../src/: system_stm32f4xx.c
  group MDK-ARM
    ./: startup_stm32f4xx.s
  group User
    ../src/: main.c netconf.c stm32f4x7_eth_bsp.c stm32f4xx_it.c fs.c httpserver-netconn.c serial_debug.c crc_16.c tcp_server.c user_record.c fatfs_func.c cJSON.c test.c usb_bsp.c usbh_usr.c print.c bootmode.c img_utils.c
    ../../../../Utilities/STM32_EVAL/STM324x7I_APP/bsp/: bsp.c
  group TASK
    ../TASK/src/: card_task.c cash_task.c dgus_task.c hopper_task.c record_task.c server_task.c start_task.c tkmeal_task.c wanwuyun_task.c usbmsc_task.c
  group LwIP
    ../../../../Utilities/Third_Party/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../../Utilities/Third_Party/lwip-1.4.1/src/core/: dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c timers.c def.c
    ../../../../Utilities/Third_Party/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../../../../Utilities/Third_Party/lwip-1.4.1/src/netif/: etharp.c
    ../../../../Utilities/Third_Party/lwip-1.4.1/port/STM32F4x7/FreeRTOS/: ethernetif.c sys_arch.c
  group STM32F4xx_StdPeriph_Driver
    ../../../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_usart.c stm32f4xx_adc.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_sdio.c stm32f4xx_syscfg.c stm32f4xx_i2c.c stm32f4xx_spi.c stm32f4xx_rtc.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_tim.c stm32f4xx_crc.c
  group STM32_USB_HOST_Library
    ../../../../Libraries/STM32_USB_HOST_Library/Core/src/: usbh_stdreq.c usbh_core.c usbh_hcs.c usbh_ioreq.c
    ../../../../Libraries/STM32_USB_OTG_Driver/src/: usb_hcd_int.c usb_core.c usb_hcd.c
    ../../../../Libraries/STM32_USB_HOST_Library/Class/MSC/src/: usbh_msc_scsi.c usbh_msc_bot.c usbh_msc_core.c usbh_msc_fatfs.c
  group STM32F4x7_ETH_Driver
    ../../../../Libraries/STM32F4x7_ETH_Driver/src/: stm32f4x7_eth.c
  group STM324xx_EVAL
    ../../../../Utilities/STM32_EVAL/STM3240_41_G_EVAL/: stm324xg_eval_lcd.c stm324xg_eval.c
    ../../../../Utilities/STM32_EVAL/STM324x7I_EVAL/: stm324x7i_eval.c stm324x7i_eval_lcd.c stm324x7i_eval_Key.c
    ../../../../Utilities/STM32_EVAL/Common/: lcd_log.c
  group STM324xx_APP
    ../../../../Utilities/STM32_EVAL/STM324x7I_APP/FLASH/: flash.c
    ../../../../Utilities/STM32_EVAL/STM324x7I_APP/SPI/: spi.c
    ../../../../Utilities/STM32_EVAL/STM324x7I_APP/sd/: sdio.c mmc_sd.c
    ../../../../Utilities/STM32_EVAL/STM324x7I_APP/usart/: uart3.c uart4.c uart1.c uart5.c
    ../../../../Utilities/STM32_EVAL/STM324x7I_APP/serialscreen/: serialscreen.c
    ../../../../Utilities/STM32_EVAL/STM324x7I_APP/printer/: printer.c
    ../../../../Utilities/STM32_EVAL/STM324x7I_APP/bill/: bill.c
    ../../../../Utilities/STM32_EVAL/STM324x7I_APP/vioce/: voice.c
    ../../../../Utilities/STM32_EVAL/STM324x7I_APP/coins/: coin.c
    ../../../../Utilities/STM32_EVAL/STM324x7I_APP/mini_hopper/: mini_hopper.c
    ../../../../Utilities/STM32_EVAL/STM324x7I_APP/delay/: delay.c
    ../../../../Utilities/STM32_EVAL/STM324x7I_APP/rtc/: rtc.c
    ../src/: gps.c
    ../../../../Utilities/STM32_EVAL/STM324x7I_APP/iap/: iap.c
    ../../../../Utilities/STM32_EVAL/STM324x7I_APP/stmflash/: stmflash.c
    ../../../../Utilities/STM32_EVAL/STM324x7I_APP/intel_flash/: intel_flash.c
  group FATFS
    ../../../../Utilities/Third_Party/FatFs_vR0.09/src/: diskio.c ff.c syscall.c cc936.c
  group FreeRTOS
    ../../../../Utilities/Third_Party/FreeRTOSV7.3.0/: tasks.c croutine.c list.c queue.c
    ../../../../Utilities/Third_Party/FreeRTOSV7.3.0/portable/RVDS/ARM_CM4F/: port.c
    ../../../../Utilities/Third_Party/FreeRTOSV7.3.0/portable/MemMang/: heap_4.c
target STM324x7I_EVAL (ARM-ADS)
  device: STM32F407IG STMicroelectronics
  cpu: as above
  output: STM324xG_EVAL +hex
  c flags: OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40XX,USE_STM324x7I_EVAL,ARM_MATH_CM4,_CC_ARM,__FPU_PRESENT=1,__FPU_USED =1,__TARGET_FPU_VFP,USE_USB_OTG_HS,USE_ULPI_PHY
  c include: ..\inc;..\..\..\..\Libraries\CMSIS\Include;..\..\..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\..\..\Libraries\STM32F4x7_ETH_Driver\inc;..\..\..\..\Utilities\STM32_EVAL\Common;..\..\..\..\Utilities\STM32_EVAL\STM324x7I_EVAL;..\..\..\..\Utilities\Third_Party\lwip-1.4.1\src\include;..\..\..\..\Utilities\Third_Party\lwip-1.4.1\src\include\lwip;..\..\..\..\Utilities\Third_Party\lwip-1.4.1\src\include\netif;..\..\..\..\Utilities\Third_Party\lwip-1.4.1\src\include\ipv4;..\..\..\..\Utilities\Third_Party\lwip-1.4.1\port\STM32F4x7;..\..\..\..\Utilities\Third_Party\lwip-1.4.1\port\STM32F4x7\FreeRTOS;..\..\..\..\Utilities\Third_Party\FreeRTOSV7.3.0\portable\RVDS\ARM_CM4F;..\..\..\..\Utilities\Third_Party\FreeRTOSV7.3.0\include;..\..\..\..\Utilities\Third_Party\FatFs_vR0.09\inc;..\..\..\..\Utilities\STM32_EVAL\STM324x7I_APP\include;..\TASK\inc;..\..\..\..\Libraries\STM32_USB_HOST_Library\Core\inc;..\..\..\..\Libraries\STM32_USB_HOST_Library\Class\MSC\inc;..\..\..\..\Libraries\STM32_USB_OTG_Driver\inc;..\..\..\..\Utilities\STM32_EVAL\Common
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x60000
  memory RVCT10: RAM 0x10000000 size 0x10000
